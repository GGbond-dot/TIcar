# Keil uVision project CtrBoard-H7_ALL.uvprojx, settings and files
target CtrBoard-H7_ALL (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrBoard-H7_ALL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../App/inc;../Bsp/inc;../vofa+;../Algorithm/inc
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  link misc: "D:\keil5_32\ARM\CMSIS\5.7.0\CMSIS\DSP\Lib\ARM\arm_cortexM7lfsp_math.lib"
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../vofa+/: vofa.c
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fdcan.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Bsp
    ../Bsp/: bsp_user_key.c bsp_buzzer.c lcd.c ws2812.c BMI088driver.c BMI088Middleware.c can_bsp.c w25q64.c bsp_dwt.c
  group App
    ../App/: key_task.c lcd_task.c imu_task.c fun_test_task.c gimbal_task.c
  group Algprithm
    ../Algorithm/: MahonyAHRS.c user_lib.c QuaternionEKF.c kalman_filter.c
software components: CMSIS:CORE 6.1.1
